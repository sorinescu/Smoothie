# Keil uVision project Smoothie.uvproj, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Smoothie +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,__USE_C99_MATH
  c include: .\src;.\src\platform\stm32\stm32f103\STM32_USB-FS-Device_Driver\inc;.\src\platform\stm32\stm32f103\STM32F10x_StdPeriph_Driver\inc;.\src\platform\shared\EASTL\include;.\src\platform\stm32\stm32f103\glue
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ./src/libs/: utils.h Adc.cpp Adc.h BasePin.h Config.cpp Config.h ConfigCache.h ConfigSource.h ConfigValue.h Digipot.h FPointer.h Hook.cpp Hook.h Kernel.cpp Kernel.h Module.cpp Module.h nuts_bolts.h Pauser.cpp Pauser.h Pin.h RingBuffer.h SerialMessage.h SlowTicker.h StepTicker.h StreamOutput.h StreamOutputPool.h utils.cpp
  group Modules
    ./src/modules/communication/utils/: Gcode.h Gcode.cpp
    ./src/modules/communication/: GcodeDispatch.h GcodeDispatch.cpp SerialConsole.h SerialConsole.cpp
    ./src/modules/robot/arm_solutions/: CartesianSolution.h BaseSolution.cpp BaseSolution.h CartesianSolution.cpp
    ./src/modules/robot/: Stepper.h Block.cpp Block.h Planner.cpp Planner.h Player.cpp Player.h Robot.cpp Robot.h Stepper.cpp
    ./src/modules/utils/configurator/: Configurator.h Configurator.cpp
  group SMP32F103
    ./src/platform/: Platform.h
    ./src/platform/stm32/: PlatformKernel.h PlatformPin.h
    ./src/platform/stm32/stm32f103/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ./src/platform/stm32/stm32f103/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c
    ./src/platform/stm32/stm32f103/: SlowTicker.cpp StepTicker.cpp Platform.cpp main.cpp USBSerial.h USBSerial.cpp
    ./src/platform/stm32/stm32f103/glue/: hw_config.h stm32f10x_conf.h system_stm32f10x.c usb_conf.h hw_config.c stm32_it.c stm32_it.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
    ./src/platform/shared/: EASTLGlue.cpp
    ./src/platform/shared/EASTL/src/: string.cpp allocator.cpp
    ./src/platform/stm32/stm32f103/glue/keil/: startup_stm32f10x_md.s
  group App
    ./src/: config.h
